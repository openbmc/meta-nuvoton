KBRANCH ?= "dev-5.8"
LINUX_VERSION ?= "5.8.17"

SRCREV="37ee9b94fc46b17e3ac56b682dff3e2fc38c47b6"

require linux-nuvoton.inc
