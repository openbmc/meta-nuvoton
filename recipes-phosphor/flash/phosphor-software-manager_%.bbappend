PACKAGECONFIG ??= "verify_signature"